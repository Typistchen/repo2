# Keil uVision project fixed_wings.uvprojx, settings and files
target fixed_wings (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Herbicidal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\systick;..\..\User\GPIO;..\..\User\led;..\..\User\Beep;..\..\User\key;..\..\User\motor;..\..\User\basic_tim;..\..\User\I2C;..\..\User\MPU6050;..\..\User\spi;..\..\User\OLED;..\..\User\Font;..\..\User\ADC;..\..\User\Ultra;..\..\User\Data_type;..\..\User\pid;..\..\User\Control;..\..\User\Mymath;..\..\User\IMU;..\..\User\steer;..\..\User\USART1_DMA;..\..\User\USART2_DMA;..\..\User\USART3_DMA;..\..\User\UART4_DMA;..\..\User\UART5_DMA;..\..\User\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/systick/: bsp_SysTick.c
    ../../User/led/: bsp_led.c
    ../../User/basic_tim/: bsp_basic_tim.c
    ../../User/Beep/: beep.c
    ../../User/motor/: motor.c
    ../../User/I2C/: I2C.c
    ../../User/MPU6050/: mpu6050.c
    ../../User/spi/: bsp_spi.c
    ../../User/pid/: pid.c
    ../../User/Control/: Control.c
    ../../User/Mymath/: Mymath.c
    ../../User/IMU/: IMU.c
    ../../User/Data_type/: Data_type.c
    ../../User/steer/: steer.c
    ../../User/USART3_DMA/: usart3_dma.c
    ../../User/USART2_DMA/: usart2_dma.c
    ../../User/sys/: sys.c
    ../../User/USART1_DMA/: usart1_dma.c
  group DOC
    ../../: 必读说明.txt
